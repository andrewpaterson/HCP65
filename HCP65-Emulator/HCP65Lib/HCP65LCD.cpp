#include <string.h>
#include "HCP65.h"
#include "HCP65LCD.h"


#define HCP65_LCD_ROM_FIRST		0x20
#define HCP65_LCD_ROM_LAST		0xFF
#define HCP65_LCD_LINE_LENGTH	40		//DDRAM addresses on each line of two.
#define HCP65_LCD_LINE_2		0x40	//The second line's first DDRAM address.


//The character ROM, from the display's datasheet (HCP65/Datasheets/NMTC-S16205DRGHS.pdf, its character font table): the
//English/Japanese set, like an HD44780U's A00 but with a few of its own shapes ('!', ',', 'A' and 'l').  Each
//character's rows, top first, the leftmost dot in D4.  $5C is a yen sign and $7E and $7F are arrows, not ASCII's
//backslash and tilde.  $E0-$FF are 5 by 10 in the ROM: in 5 by 8 their top eight rows show, so descenders are cut off.
//$80-$9F are blank.
static const uint8 gaauiHCP65LCDFont[HCP65_LCD_ROM_LAST - HCP65_LCD_ROM_FIRST + 1][HCP65_LCD_CHARACTER_HEIGHT] =
{
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$20 space
	{ 0x04, 0x04, 0x04, 0x04, 0x00, 0x00, 0x04, 0x00 },	//$21 !
	{ 0x0A, 0x0A, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$22 "
	{ 0x0A, 0x0A, 0x1F, 0x0A, 0x1F, 0x0A, 0x0A, 0x00 },	//$23 #
	{ 0x04, 0x0F, 0x14, 0x0E, 0x05, 0x1E, 0x04, 0x00 },	//$24 $
	{ 0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03, 0x00 },	//$25 %
	{ 0x0C, 0x12, 0x14, 0x08, 0x15, 0x12, 0x0D, 0x00 },	//$26 &
	{ 0x0C, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$27 '
	{ 0x02, 0x04, 0x08, 0x08, 0x08, 0x04, 0x02, 0x00 },	//$28 (
	{ 0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0x08, 0x00 },	//$29 )
	{ 0x00, 0x04, 0x15, 0x0E, 0x15, 0x04, 0x00, 0x00 },	//$2A *
	{ 0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00, 0x00 },	//$2B +
	{ 0x00, 0x00, 0x00, 0x0C, 0x04, 0x08, 0x00, 0x00 },	//$2C ,
	{ 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00 },	//$2D -
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00 },	//$2E .
	{ 0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x00, 0x00 },	//$2F /
	{ 0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E, 0x00 },	//$30 0
	{ 0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E, 0x00 },	//$31 1
	{ 0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F, 0x00 },	//$32 2
	{ 0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E, 0x00 },	//$33 3
	{ 0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02, 0x00 },	//$34 4
	{ 0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E, 0x00 },	//$35 5
	{ 0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E, 0x00 },	//$36 6
	{ 0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08, 0x00 },	//$37 7
	{ 0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E, 0x00 },	//$38 8
	{ 0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C, 0x00 },	//$39 9
	{ 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x00 },	//$3A :
	{ 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x04, 0x08, 0x00 },	//$3B ;
	{ 0x02, 0x04, 0x08, 0x10, 0x08, 0x04, 0x02, 0x00 },	//$3C <
	{ 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00 },	//$3D =
	{ 0x08, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08, 0x00 },	//$3E >
	{ 0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04, 0x00 },	//$3F ?
	{ 0x0E, 0x11, 0x01, 0x0D, 0x15, 0x15, 0x0E, 0x00 },	//$40 @
	{ 0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11, 0x00 },	//$41 A
	{ 0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E, 0x00 },	//$42 B
	{ 0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E, 0x00 },	//$43 C
	{ 0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C, 0x00 },	//$44 D
	{ 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F, 0x00 },	//$45 E
	{ 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10, 0x00 },	//$46 F
	{ 0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F, 0x00 },	//$47 G
	{ 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11, 0x00 },	//$48 H
	{ 0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E, 0x00 },	//$49 I
	{ 0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C, 0x00 },	//$4A J
	{ 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11, 0x00 },	//$4B K
	{ 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x00 },	//$4C L
	{ 0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11, 0x00 },	//$4D M
	{ 0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x00 },	//$4E N
	{ 0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E, 0x00 },	//$4F O
	{ 0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10, 0x00 },	//$50 P
	{ 0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D, 0x00 },	//$51 Q
	{ 0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11, 0x00 },	//$52 R
	{ 0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E, 0x00 },	//$53 S
	{ 0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00 },	//$54 T
	{ 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E, 0x00 },	//$55 U
	{ 0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04, 0x00 },	//$56 V
	{ 0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A, 0x00 },	//$57 W
	{ 0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11, 0x00 },	//$58 X
	{ 0x11, 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x00 },	//$59 Y
	{ 0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F, 0x00 },	//$5A Z
	{ 0x0E, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0E, 0x00 },	//$5B [
	{ 0x11, 0x0A, 0x1F, 0x04, 0x1F, 0x04, 0x04, 0x00 },	//$5C yen
	{ 0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x0E, 0x00 },	//$5D ]
	{ 0x04, 0x0A, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$5E ^
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00 },	//$5F _
	{ 0x08, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$60 `
	{ 0x00, 0x00, 0x0E, 0x01, 0x0F, 0x11, 0x0F, 0x00 },	//$61 a
	{ 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x1E, 0x00 },	//$62 b
	{ 0x00, 0x00, 0x0E, 0x10, 0x10, 0x11, 0x0E, 0x00 },	//$63 c
	{ 0x01, 0x01, 0x0D, 0x13, 0x11, 0x11, 0x0F, 0x00 },	//$64 d
	{ 0x00, 0x00, 0x0E, 0x11, 0x1F, 0x10, 0x0E, 0x00 },	//$65 e
	{ 0x06, 0x09, 0x08, 0x1C, 0x08, 0x08, 0x08, 0x00 },	//$66 f
	{ 0x00, 0x0F, 0x11, 0x11, 0x0F, 0x01, 0x0E, 0x00 },	//$67 g
	{ 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00 },	//$68 h
	{ 0x04, 0x00, 0x0C, 0x04, 0x04, 0x04, 0x0E, 0x00 },	//$69 i
	{ 0x02, 0x00, 0x06, 0x02, 0x02, 0x12, 0x0C, 0x00 },	//$6A j
	{ 0x10, 0x10, 0x12, 0x14, 0x18, 0x14, 0x12, 0x00 },	//$6B k
	{ 0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1F, 0x00 },	//$6C l
	{ 0x00, 0x00, 0x1A, 0x15, 0x15, 0x11, 0x11, 0x00 },	//$6D m
	{ 0x00, 0x00, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00 },	//$6E n
	{ 0x00, 0x00, 0x0E, 0x11, 0x11, 0x11, 0x0E, 0x00 },	//$6F o
	{ 0x00, 0x00, 0x1E, 0x11, 0x1E, 0x10, 0x10, 0x00 },	//$70 p
	{ 0x00, 0x00, 0x0D, 0x13, 0x0F, 0x01, 0x01, 0x00 },	//$71 q
	{ 0x00, 0x00, 0x16, 0x19, 0x10, 0x10, 0x10, 0x00 },	//$72 r
	{ 0x00, 0x00, 0x0E, 0x10, 0x0E, 0x01, 0x1E, 0x00 },	//$73 s
	{ 0x08, 0x08, 0x1C, 0x08, 0x08, 0x09, 0x06, 0x00 },	//$74 t
	{ 0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0D, 0x00 },	//$75 u
	{ 0x00, 0x00, 0x11, 0x11, 0x11, 0x0A, 0x04, 0x00 },	//$76 v
	{ 0x00, 0x00, 0x11, 0x11, 0x15, 0x15, 0x0A, 0x00 },	//$77 w
	{ 0x00, 0x00, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x00 },	//$78 x
	{ 0x00, 0x00, 0x11, 0x11, 0x0F, 0x01, 0x0E, 0x00 },	//$79 y
	{ 0x00, 0x00, 0x1F, 0x02, 0x04, 0x08, 0x1F, 0x00 },	//$7A z
	{ 0x02, 0x04, 0x04, 0x08, 0x04, 0x04, 0x02, 0x00 },	//$7B {
	{ 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00 },	//$7C |
	{ 0x08, 0x04, 0x04, 0x02, 0x04, 0x04, 0x08, 0x00 },	//$7D }
	{ 0x00, 0x04, 0x02, 0x1F, 0x02, 0x04, 0x00, 0x00 },	//$7E ~
	{ 0x00, 0x04, 0x08, 0x1F, 0x08, 0x04, 0x00, 0x00 },	//$7F left arrow
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$80
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$81
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$82
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$83
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$84
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$85
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$86
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$87
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$88
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$89
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$8A
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$8B
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$8C
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$8D
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$8E
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$8F
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$90
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$91
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$92
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$93
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$94
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$95
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$96
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$97
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$98
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$99
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$9A
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$9B
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$9C
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$9D
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$9E
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$9F
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$A0
	{ 0x00, 0x00, 0x00, 0x00, 0x1C, 0x14, 0x1C, 0x00 },	//$A1
	{ 0x07, 0x04, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00 },	//$A2
	{ 0x00, 0x00, 0x00, 0x04, 0x04, 0x04, 0x1C, 0x00 },	//$A3
	{ 0x00, 0x00, 0x00, 0x00, 0x10, 0x08, 0x04, 0x00 },	//$A4
	{ 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00 },	//$A5
	{ 0x00, 0x1F, 0x01, 0x1F, 0x01, 0x02, 0x04, 0x00 },	//$A6
	{ 0x00, 0x00, 0x1F, 0x01, 0x06, 0x04, 0x08, 0x00 },	//$A7
	{ 0x00, 0x00, 0x02, 0x04, 0x0C, 0x14, 0x04, 0x00 },	//$A8
	{ 0x00, 0x00, 0x04, 0x1F, 0x11, 0x01, 0x0E, 0x00 },	//$A9
	{ 0x00, 0x00, 0x00, 0x1F, 0x04, 0x04, 0x1F, 0x00 },	//$AA
	{ 0x00, 0x00, 0x02, 0x1F, 0x06, 0x0A, 0x12, 0x00 },	//$AB
	{ 0x00, 0x00, 0x08, 0x1F, 0x09, 0x0A, 0x08, 0x00 },	//$AC
	{ 0x00, 0x00, 0x00, 0x0E, 0x02, 0x02, 0x1F, 0x00 },	//$AD
	{ 0x00, 0x00, 0x1E, 0x02, 0x1E, 0x02, 0x1E, 0x00 },	//$AE
	{ 0x00, 0x00, 0x00, 0x15, 0x15, 0x01, 0x06, 0x00 },	//$AF
	{ 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00 },	//$B0
	{ 0x1F, 0x01, 0x05, 0x06, 0x04, 0x04, 0x08, 0x00 },	//$B1
	{ 0x01, 0x02, 0x04, 0x0C, 0x14, 0x04, 0x04, 0x00 },	//$B2
	{ 0x04, 0x1F, 0x11, 0x11, 0x01, 0x02, 0x04, 0x00 },	//$B3
	{ 0x00, 0x1F, 0x04, 0x04, 0x04, 0x04, 0x1F, 0x00 },	//$B4
	{ 0x02, 0x1F, 0x02, 0x06, 0x0A, 0x12, 0x02, 0x00 },	//$B5
	{ 0x08, 0x1F, 0x09, 0x09, 0x09, 0x09, 0x12, 0x00 },	//$B6
	{ 0x04, 0x1F, 0x04, 0x1F, 0x04, 0x04, 0x04, 0x00 },	//$B7
	{ 0x00, 0x0F, 0x09, 0x11, 0x01, 0x02, 0x0C, 0x00 },	//$B8
	{ 0x08, 0x0F, 0x12, 0x02, 0x02, 0x02, 0x04, 0x00 },	//$B9
	{ 0x00, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x00 },	//$BA
	{ 0x0A, 0x1F, 0x0A, 0x0A, 0x02, 0x04, 0x08, 0x00 },	//$BB
	{ 0x00, 0x18, 0x01, 0x19, 0x01, 0x02, 0x1C, 0x00 },	//$BC
	{ 0x00, 0x1F, 0x01, 0x02, 0x04, 0x0A, 0x11, 0x00 },	//$BD
	{ 0x08, 0x1F, 0x09, 0x0A, 0x08, 0x08, 0x07, 0x00 },	//$BE
	{ 0x00, 0x11, 0x11, 0x09, 0x01, 0x02, 0x0C, 0x00 },	//$BF
	{ 0x00, 0x0F, 0x09, 0x15, 0x03, 0x02, 0x0C, 0x00 },	//$C0
	{ 0x02, 0x1C, 0x04, 0x1F, 0x04, 0x04, 0x08, 0x00 },	//$C1
	{ 0x00, 0x15, 0x15, 0x15, 0x01, 0x02, 0x04, 0x00 },	//$C2
	{ 0x0E, 0x00, 0x1F, 0x04, 0x04, 0x04, 0x08, 0x00 },	//$C3
	{ 0x08, 0x08, 0x08, 0x0C, 0x0A, 0x08, 0x08, 0x00 },	//$C4
	{ 0x04, 0x04, 0x1F, 0x04, 0x04, 0x08, 0x10, 0x00 },	//$C5
	{ 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00 },	//$C6
	{ 0x00, 0x1F, 0x01, 0x0A, 0x04, 0x0A, 0x10, 0x00 },	//$C7
	{ 0x04, 0x1F, 0x02, 0x04, 0x0E, 0x15, 0x04, 0x00 },	//$C8
	{ 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x00 },	//$C9
	{ 0x00, 0x04, 0x02, 0x11, 0x11, 0x11, 0x11, 0x00 },	//$CA
	{ 0x10, 0x10, 0x1F, 0x10, 0x10, 0x10, 0x0F, 0x00 },	//$CB
	{ 0x00, 0x1F, 0x01, 0x01, 0x01, 0x02, 0x0C, 0x00 },	//$CC
	{ 0x00, 0x08, 0x14, 0x02, 0x01, 0x01, 0x00, 0x00 },	//$CD
	{ 0x04, 0x1F, 0x04, 0x04, 0x15, 0x15, 0x04, 0x00 },	//$CE
	{ 0x00, 0x1F, 0x01, 0x01, 0x0A, 0x04, 0x02, 0x00 },	//$CF
	{ 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x01, 0x00 },	//$D0
	{ 0x00, 0x04, 0x08, 0x10, 0x11, 0x1F, 0x01, 0x00 },	//$D1
	{ 0x00, 0x01, 0x01, 0x0A, 0x04, 0x0A, 0x10, 0x00 },	//$D2
	{ 0x00, 0x1F, 0x08, 0x1F, 0x08, 0x08, 0x07, 0x00 },	//$D3
	{ 0x08, 0x08, 0x1F, 0x09, 0x0A, 0x08, 0x08, 0x00 },	//$D4
	{ 0x00, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x1F, 0x00 },	//$D5
	{ 0x00, 0x1F, 0x01, 0x1F, 0x01, 0x01, 0x1F, 0x00 },	//$D6
	{ 0x0E, 0x00, 0x1F, 0x01, 0x01, 0x02, 0x04, 0x00 },	//$D7
	{ 0x12, 0x12, 0x12, 0x12, 0x02, 0x04, 0x08, 0x00 },	//$D8
	{ 0x00, 0x04, 0x14, 0x14, 0x15, 0x15, 0x16, 0x00 },	//$D9
	{ 0x00, 0x10, 0x10, 0x11, 0x12, 0x14, 0x18, 0x00 },	//$DA
	{ 0x00, 0x1F, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x00 },	//$DB
	{ 0x00, 0x1F, 0x11, 0x11, 0x01, 0x02, 0x04, 0x00 },	//$DC
	{ 0x00, 0x18, 0x00, 0x01, 0x01, 0x02, 0x1C, 0x00 },	//$DD
	{ 0x04, 0x12, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$DE
	{ 0x1C, 0x14, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$DF
	{ 0x00, 0x00, 0x09, 0x15, 0x12, 0x12, 0x0D, 0x00 },	//$E0
	{ 0x0A, 0x00, 0x0E, 0x01, 0x0F, 0x11, 0x0F, 0x00 },	//$E1
	{ 0x00, 0x00, 0x00, 0x0E, 0x11, 0x1E, 0x11, 0x1E },	//$E2
	{ 0x00, 0x00, 0x0E, 0x10, 0x0C, 0x11, 0x0E, 0x00 },	//$E3
	{ 0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x1D, 0x10 },	//$E4
	{ 0x00, 0x00, 0x0F, 0x14, 0x12, 0x11, 0x0E, 0x00 },	//$E5
	{ 0x00, 0x00, 0x06, 0x09, 0x11, 0x11, 0x1E, 0x10 },	//$E6
	{ 0x00, 0x00, 0x0F, 0x11, 0x11, 0x11, 0x0F, 0x01 },	//$E7
	{ 0x00, 0x00, 0x07, 0x04, 0x04, 0x14, 0x08, 0x00 },	//$E8
	{ 0x00, 0x02, 0x1A, 0x02, 0x00, 0x00, 0x00, 0x00 },	//$E9
	{ 0x02, 0x00, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02 },	//$EA
	{ 0x00, 0x14, 0x08, 0x14, 0x00, 0x00, 0x00, 0x00 },	//$EB
	{ 0x00, 0x04, 0x0E, 0x14, 0x15, 0x0E, 0x04, 0x00 },	//$EC
	{ 0x08, 0x08, 0x1C, 0x08, 0x1C, 0x08, 0x0F, 0x00 },	//$ED
	{ 0x0E, 0x00, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00 },	//$EE
	{ 0x0A, 0x00, 0x0E, 0x11, 0x11, 0x11, 0x0E, 0x00 },	//$EF
	{ 0x00, 0x00, 0x16, 0x19, 0x11, 0x11, 0x1E, 0x10 },	//$F0
	{ 0x00, 0x00, 0x0D, 0x13, 0x11, 0x11, 0x0F, 0x01 },	//$F1
	{ 0x00, 0x00, 0x0E, 0x11, 0x1F, 0x11, 0x11, 0x0E },	//$F2
	{ 0x00, 0x00, 0x00, 0x0B, 0x15, 0x1A, 0x00, 0x00 },	//$F3
	{ 0x00, 0x00, 0x0E, 0x11, 0x11, 0x0A, 0x1B, 0x00 },	//$F4
	{ 0x0A, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0D, 0x00 },	//$F5
	{ 0x1F, 0x10, 0x08, 0x04, 0x08, 0x10, 0x1F, 0x00 },	//$F6
	{ 0x00, 0x00, 0x1F, 0x0A, 0x0A, 0x0A, 0x13, 0x00 },	//$F7
	{ 0x1F, 0x00, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x00 },	//$F8
	{ 0x00, 0x00, 0x11, 0x11, 0x11, 0x11, 0x0F, 0x01 },	//$F9
	{ 0x00, 0x01, 0x1E, 0x04, 0x1F, 0x04, 0x04, 0x00 },	//$FA
	{ 0x00, 0x00, 0x1F, 0x08, 0x0F, 0x09, 0x11, 0x00 },	//$FB
	{ 0x00, 0x00, 0x1F, 0x15, 0x1F, 0x11, 0x11, 0x00 },	//$FC
	{ 0x00, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x04, 0x00 },	//$FD
	{ 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 },	//$FE
	{ 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F },	//$FF all dots
};


//////////////////////////////////////////////////////////////////////////
//
// As power leaves it: busy with its own reset (PowerOn).
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::Init(uint64 uiCyclesPerSecond)
{
	muiCyclesPerSecond = uiCyclesPerSecond;
	memset(mauiCGRAM, 0, HCP65_LCD_CGRAM_SIZE);
	mbE = false;
	mbRS = false;
	mbRead = false;
	muiIgnored = 0;
	PowerOn(0);
}


//////////////////////////////////////////////////////////////////////////
//
// Its reset on power: the display cleared and off, eight bit, one line,
// the address counter incrementing, and busy for HCP65_LCD_POWER_ON_US.
// CGRAM isn't cleared.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::PowerOn(uint64 uiCycle)
{
	memset(mauiDDRAM, ' ', HCP65_LCD_DDRAM_SIZE);
	muiAddress = 0;
	mbCGRAM = false;
	mbIncrement = true;
	mbShiftOnWrite = false;
	mbDisplayOn = false;
	mbCursor = false;
	mbBlink = false;
	mbEightBit = true;
	mbTwoLines = false;
	mbLargeFont = false;
	muiShift = 0;
	mbLowNibble = false;
	muiHighNibble = 0;
	mbDataRead = false;
	muiDataRegister = 0;
	muiBusyUntil = 0;
	Busy(uiCycle, HCP65_LCD_POWER_ON_US);
}


//////////////////////////////////////////////////////////////////////////
//
// The pins as they are from uiCycle.  E falling ends a transfer: one that
// was a write takes uiDB (with RS and R/~W as they were while E was high).
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::SetPins(bool bE, bool bRS, bool bRead, uint8 uiDB, uint64 uiCycle)
{
	if (mbE && !bE)
	{
		if (!mbRead)
		{
			Transfer(mbRS, uiDB, uiCycle);
		}
		else
		{
			//A read is two transfers in four bit mode, the high four bits first.
			if (!mbEightBit)
			{
				mbLowNibble = !mbLowNibble;
			}
			if (mbDataRead && (mbEightBit || !mbLowNibble))
			{
				MoveAddress(mbIncrement);
				muiDataRegister = ReadData();
				Busy(uiCycle, HCP65_LCD_DATA_US);
			}
		}
		mbDataRead = false;
	}
	mbE = bE;
	mbRS = bRS;
	mbRead = bRead;
}


//////////////////////////////////////////////////////////////////////////
//
// The controller drives DB0-DB7 while E is high and R/~W is high.
//
//////////////////////////////////////////////////////////////////////////
bool CHCP65LCDController::IsDriving(void) const
{
	return mbE && mbRead;
}


//////////////////////////////////////////////////////////////////////////
//
// What it drives: the busy flag in D7 and the address counter, or the
// data register.  That was loaded from the address counter's RAM when
// the address was set, the cursor moved or the last read moved on, not
// by a write: a read straight after a write gives what was there before
// (the datasheet's note on Read Data).  In four bit mode the half of it
// this transfer is in D4-D7, and D0-D3 aren't driven.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDController::GetOutput(uint64 uiCycle)
{
	uint8	uiValue;

	if (mbRS)
	{
		uiValue = muiDataRegister;
		mbDataRead = true;
	}
	else
	{
		uiValue = (uint8)(muiAddress & 0x7F);
		if (IsBusy(uiCycle))
		{
			uiValue |= 0x80;
		}
	}
	if (!mbEightBit)
	{
		uiValue = mbLowNibble ? (uint8)((uiValue << 4) | 0x0F) : (uint8)(uiValue | 0x0F);
	}
	return uiValue;
}


//////////////////////////////////////////////////////////////////////////
//
// A byte, or in four bit mode half of one, written to the instruction
// register (RS low) or as data.  Dropped while busy.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::Transfer(bool bRS, uint8 uiValue, uint64 uiCycle)
{
	if (!mbEightBit)
	{
		if (!mbLowNibble)
		{
			muiHighNibble = (uint8)(uiValue & 0xF0);
			mbLowNibble = true;
			return;
		}
		uiValue = (uint8)(muiHighNibble | (uiValue >> 4));
		mbLowNibble = false;
	}

	if (IsBusy(uiCycle))
	{
		muiIgnored++;
		return;
	}
	if (bRS)
	{
		WriteData(uiValue);
		Busy(uiCycle, HCP65_LCD_DATA_US);
	}
	else
	{
		Instruction(uiValue, uiCycle);
	}
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::Instruction(uint8 uiValue, uint64 uiCycle)
{
	if (uiValue & 0x80)
	{
		//Set DDRAM address.
		muiAddress = (uint8)(uiValue & 0x7F);
		mbCGRAM = false;
		muiDataRegister = ReadData();
	}
	else if (uiValue & 0x40)
	{
		//Set CGRAM address.
		muiAddress = (uint8)(uiValue & 0x3F);
		mbCGRAM = true;
		muiDataRegister = ReadData();
	}
	else if (uiValue & 0x20)
	{
		//Function set: DL, N and F.  Four bit mode starts with the next transfer.
		mbEightBit = (uiValue & 0x10) != 0;
		mbTwoLines = (uiValue & 0x08) != 0;
		mbLargeFont = (uiValue & 0x04) != 0;
		mbLowNibble = false;
	}
	else if (uiValue & 0x10)
	{
		//Cursor or display shift: S/C and R/L.
		if (uiValue & 0x08)
		{
			ShiftDisplay((uiValue & 0x04) == 0);
		}
		else
		{
			MoveAddress((uiValue & 0x04) != 0);
			muiDataRegister = ReadData();
		}
	}
	else if (uiValue & 0x08)
	{
		//Display on/off control: D, C and B.
		mbDisplayOn = (uiValue & 0x04) != 0;
		mbCursor = (uiValue & 0x02) != 0;
		mbBlink = (uiValue & 0x01) != 0;
	}
	else if (uiValue & 0x04)
	{
		//Entry mode set: I/D and S.
		mbIncrement = (uiValue & 0x02) != 0;
		mbShiftOnWrite = (uiValue & 0x01) != 0;
	}
	else if (uiValue & 0x02)
	{
		//Return home.
		muiAddress = 0;
		mbCGRAM = false;
		muiShift = 0;
		Busy(uiCycle, HCP65_LCD_CLEAR_US);
		return;
	}
	else if (uiValue & 0x01)
	{
		//Clear display: spaces, the address counter 0 and incrementing, and no shift.
		memset(mauiDDRAM, ' ', HCP65_LCD_DDRAM_SIZE);
		muiAddress = 0;
		mbCGRAM = false;
		mbIncrement = true;
		muiShift = 0;
		Busy(uiCycle, HCP65_LCD_CLEAR_US);
		return;
	}
	Busy(uiCycle, HCP65_LCD_INSTRUCTION_US);
}


//////////////////////////////////////////////////////////////////////////
//
// The data at the address counter, which then moves; a DDRAM write
// shifts the display with it if the entry mode says to.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::WriteData(uint8 uiValue)
{
	if (mbCGRAM)
	{
		mauiCGRAM[muiAddress & 0x3F] = uiValue;
	}
	else
	{
		mauiDDRAM[DDRAMIndex(muiAddress)] = uiValue;
		if (mbShiftOnWrite)
		{
			ShiftDisplay(mbIncrement);
		}
	}
	MoveAddress(mbIncrement);
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDController::ReadData(void) const
{
	if (mbCGRAM)
	{
		return mauiCGRAM[muiAddress & 0x3F];
	}
	return mauiDDRAM[DDRAMIndex(muiAddress)];
}


//////////////////////////////////////////////////////////////////////////
//
// The address counter one on or back.  On two lines DDRAM runs $00-$27
// then $40-$67 and round; on one, $00-$4F.  CGRAM runs $00-$3F.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::MoveAddress(bool bIncrement)
{
	if (mbCGRAM)
	{
		muiAddress = (uint8)((muiAddress + (bIncrement ? 1 : -1)) & 0x3F);
	}
	else if (mbTwoLines)
	{
		if (bIncrement)
		{
			muiAddress = (muiAddress == 0x27) ? HCP65_LCD_LINE_2 : (muiAddress == 0x67) ? 0x00 : (uint8)((muiAddress + 1) & 0x7F);
		}
		else
		{
			muiAddress = (muiAddress == 0x00) ? 0x67 : (muiAddress == HCP65_LCD_LINE_2) ? 0x27 : (uint8)((muiAddress - 1) & 0x7F);
		}
	}
	else
	{
		if (bIncrement)
		{
			muiAddress = (muiAddress >= 0x4F) ? 0x00 : (uint8)(muiAddress + 1);
		}
		else
		{
			muiAddress = (muiAddress == 0x00) ? 0x4F : (uint8)(muiAddress - 1);
		}
	}
}


//////////////////////////////////////////////////////////////////////////
//
// Both lines move together: left shows what is further on.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::ShiftDisplay(bool bLeft)
{
	uint8	uiLength;

	uiLength = mbTwoLines ? HCP65_LCD_LINE_LENGTH : HCP65_LCD_DDRAM_SIZE;
	if (bLeft)
	{
		muiShift = (uint8)((muiShift + 1) % uiLength);
	}
	else
	{
		muiShift = (uint8)((muiShift + uiLength - 1) % uiLength);
	}
}


//////////////////////////////////////////////////////////////////////////
//
// Where a DDRAM address is in its 80 bytes: the second line's $40-$67 is
// the same RAM as one line's $28-$4F.  Addresses past a line's end (which
// the controller doesn't have) fold back into it.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDController::DDRAMIndex(uint8 uiAddress) const
{
	if (mbTwoLines)
	{
		if (uiAddress & HCP65_LCD_LINE_2)
		{
			return (uint8)(HCP65_LCD_LINE_LENGTH + (uiAddress & 0x3F) % HCP65_LCD_LINE_LENGTH);
		}
		return (uint8)((uiAddress & 0x3F) % HCP65_LCD_LINE_LENGTH);
	}
	return (uint8)(uiAddress % HCP65_LCD_DDRAM_SIZE);
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::Busy(uint64 uiCycle, uint32 uiMicroseconds)
{
	muiBusyUntil = uiCycle + (muiCyclesPerSecond * uiMicroseconds + 999999) / 1000000;
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
bool CHCP65LCDController::IsBusy(uint64 uiCycle) const
{
	return uiCycle < muiBusyUntil;
}


uint8 CHCP65LCDController::GetAddress(void) const { return muiAddress; }
uint8 CHCP65LCDController::GetDDRAM(uint8 uiAddress) const { return mauiDDRAM[DDRAMIndex(uiAddress)]; }
uint8 CHCP65LCDController::GetCGRAM(uint8 uiAddress) const { return mauiCGRAM[uiAddress & 0x3F]; }
uint64 CHCP65LCDController::NumIgnored(void) const { return muiIgnored; }


//////////////////////////////////////////////////////////////////////////
//
// One row of a character's dots: CGRAM's for $00-$0F (eight characters,
// twice over), the ROM's for $20-$FF; $10-$1F are blank.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDController::Glyph(uint8 uiCode, int iRow) const
{
	if (uiCode < 0x10)
	{
		return (uint8)(mauiCGRAM[((uiCode & 0x07) * HCP65_LCD_CHARACTER_HEIGHT) + iRow] & 0x1F);
	}
	if (uiCode >= HCP65_LCD_ROM_FIRST)
	{
		return gaauiHCP65LCDFont[uiCode - HCP65_LCD_ROM_FIRST][iRow];
	}
	return 0;
}


//////////////////////////////////////////////////////////////////////////
//
// What the display shows at uiCycle: the first line, and the second on
// two lines, from where the display is shifted to.  The cursor is the
// last row of the character at the address counter, and blinking makes
// that character all dots every other HCP65_LCD_BLINK_US.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDController::GetPicture(SHCP65LCDPicture* psPicture, uint64 uiCycle) const
{
	int		iRow;
	int		iColumn;
	int		iDot;
	uint8	uiAddress;
	uint8	uiCode;
	bool	bBlinkOn;
	uint64	uiBlinkCycles;

	memset(psPicture->aauiDots, 0, sizeof(psPicture->aauiDots));
	psPicture->bOn = mbDisplayOn;
	if (!mbDisplayOn)
	{
		return;
	}

	uiBlinkCycles = (muiCyclesPerSecond * HCP65_LCD_BLINK_US) / 1000000;
	bBlinkOn = (uiBlinkCycles == 0) || (((uiCycle / uiBlinkCycles) & 1) == 0);
	for (iRow = 0; iRow < (mbTwoLines ? HCP65_LCD_ROWS : 1); iRow++)
	{
		for (iColumn = 0; iColumn < HCP65_LCD_COLUMNS; iColumn++)
		{
			if (mbTwoLines)
			{
				uiAddress = (uint8)((iRow * HCP65_LCD_LINE_2) + ((iColumn + muiShift) % HCP65_LCD_LINE_LENGTH));
			}
			else
			{
				uiAddress = (uint8)((iColumn + muiShift) % HCP65_LCD_DDRAM_SIZE);
			}
			uiCode = mauiDDRAM[DDRAMIndex(uiAddress)];
			for (iDot = 0; iDot < HCP65_LCD_CHARACTER_HEIGHT; iDot++)
			{
				psPicture->aauiDots[iRow][iColumn][iDot] = Glyph(uiCode, iDot);
			}
			if (!mbCGRAM && (DDRAMIndex(uiAddress) == DDRAMIndex(muiAddress)))
			{
				if (mbCursor)
				{
					psPicture->aauiDots[iRow][iColumn][HCP65_LCD_CHARACTER_HEIGHT - 1] = 0x1F;
				}
				if (mbBlink && bBlinkOn)
				{
					memset(psPicture->aauiDots[iRow][iColumn], 0x1F, HCP65_LCD_CHARACTER_HEIGHT);
				}
			}
		}
	}
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::Init(void)
{
	int		i;

	CHCP65Device::Init(HCP65_SMALL_SLOT_SIZE);
	mcROM.Init(HCP65_LCD_BOARD_NAME, HCP65_DEVICE_MANUFACTURER, 0, DEVICE_BUS_32KB, 0, HCP65_LCD_BOARD_DRIVER);
	mcROM.AddRegisters(HCP65_LCD_REGISTERS + HCP65_LCD_COMMAND, 8, DEVICE_REGISTER_READ);
	mcROM.AddRegisters(HCP65_LCD_REGISTERS + HCP65_LCD_COMMAND, 8, DEVICE_REGISTER_WRITE);
	mcROM.AddRegisters(HCP65_LCD_REGISTERS + HCP65_LCD_SNES_1_LOW, 4, DEVICE_REGISTER_READ);
	mcMutex.Init();
	mcController.Init(HCP65_DEFAULT_CLOCK_RATE);
	muiPins = 0;
	muiData = 0;
	muiCycle = 0;
	mbPoweredOn = false;
	for (i = 0; i < HCP65_SNES_CONTROLLERS; i++)
	{
		mauiButtons[i] = 0;
		mauiLatched[i] = 0;
	}
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::Kill(void)
{
	mcMutex.Kill();
	CHCP65Device::Kill();
}


//////////////////////////////////////////////////////////////////////////
//
// The display's power comes on with the HCP65's: its time starts at the
// first cycle the board sees, at the HCP65's clock rate.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::PowerOn(void)
{
	if (mbPoweredOn)
	{
		return;
	}
	mbPoweredOn = true;
	mcMutex.Lock();
	mcController.Init(mpcHCP65 ? mpcHCP65->GetClockRate() : HCP65_DEFAULT_CLOCK_RATE);
	mcController.PowerOn(muiCycle);
	mcMutex.Unlock();
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::CatchUp(uint64 uiCycle)
{
	muiCycle = uiCycle;
	PowerOn();
}


//////////////////////////////////////////////////////////////////////////
//
// A reset holds the SNES clock: the latches keep what they have.  The
// display has no reset.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::Reset(void)
{
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDBoard::Read(uint32 uiOffset)
{
	if (uiOffset < DEVICE_ROM_SIZE)
	{
		return mcROM.Read(uiOffset);
	}
	if (uiOffset < 0x800)
	{
		return Access(uiOffset & 0x0F, false, 0);
	}
	return 0xFF;
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::Write(uint32 uiOffset, uint8 uiValue)
{
	if ((uiOffset >= DEVICE_ROM_SIZE) && (uiOffset < 0x800))
	{
		Access(uiOffset & 0x0F, true, uiValue);
	}
}


//////////////////////////////////////////////////////////////////////////
//
// An access to $400-$407 sets the display's pins from its address, the
// display seeing the byte latched before it; a write then latches its
// byte.  $408-$40B read the SNES latches.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDBoard::Access(uint32 uiRegister, bool bWrite, uint8 uiValue)
{
	uint8	uiResult;

	if (mpcHCP65 && (mpcHCP65->NumCycles() > muiCycle))
	{
		muiCycle = mpcHCP65->NumCycles();
	}
	PowerOn();
	if (uiRegister >= HCP65_LCD_SNES_1_LOW)
	{
		if (bWrite || (uiRegister > HCP65_LCD_SNES_2_HIGH))
		{
			return 0xFF;
		}
		return ReadController((uiRegister - HCP65_LCD_SNES_1_LOW) / 2, (uiRegister & 1) != 0);
	}

	mcMutex.Lock();
	muiPins = (uint8)uiRegister;
	mcController.SetPins((muiPins & HCP65_LCD_E) != 0, (muiPins & HCP65_LCD_RS) != 0, (muiPins & HCP65_LCD_READ) != 0, muiData, muiCycle);
	if (bWrite)
	{
		muiData = uiValue;
	}
	if (!(muiPins & HCP65_LCD_READ))
	{
		uiResult = muiData;
	}
	else if (mcController.IsDriving())
	{
		uiResult = mcController.GetOutput(muiCycle);
	}
	else
	{
		uiResult = 0xFF;
	}
	mcMutex.Unlock();
	return uiResult;
}


//////////////////////////////////////////////////////////////////////////
//
// Its latches, 0 for pressed: the high register is the first eight
// buttons it sends, the low one the last four and four that are never
// pressed.  They follow the buttons unless the board is held in reset.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDBoard::ReadController(int iController, bool bHigh)
{
	uint16	uiSent;

	if (!mbHeldInReset)
	{
		mauiLatched[iController] = mauiButtons[iController];
	}
	uiSent = (uint16)~mauiLatched[iController];
	return bHigh ? (uint8)uiSent : (uint8)((uiSent >> 8) | 0xF0);
}


//////////////////////////////////////////////////////////////////////////
//
// iController's buttons now, as HCP65_SNES_*: 0 for none pressed or for
// no controller plugged in.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::SetButtons(int iController, uint16 uiButtons)
{
	if ((iController >= 0) && (iController < HCP65_SNES_CONTROLLERS))
	{
		mauiButtons[iController] = (uint16)(uiButtons & HCP65_SNES_BUTTONS);
	}
}


//////////////////////////////////////////////////////////////////////////
//
// From any thread.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65LCDBoard::GetPicture(SHCP65LCDPicture* psPicture, uint64 uiCycle)
{
	mcMutex.Lock();
	mcController.GetPicture(psPicture, uiCycle);
	mcMutex.Unlock();
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
bool CHCP65LCDBoard::IsBusy(void)
{
	bool	bBusy;

	mcMutex.Lock();
	bBusy = mcController.IsBusy(muiCycle);
	mcMutex.Unlock();
	return bBusy;
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65LCDBoard::GetDDRAM(uint8 uiAddress)
{
	uint8	uiValue;

	mcMutex.Lock();
	uiValue = mcController.GetDDRAM(uiAddress);
	mcMutex.Unlock();
	return uiValue;
}


//////////////////////////////////////////////////////////////////////////
//
// Instructions and data the controller was given while busy.
//
//////////////////////////////////////////////////////////////////////////
uint64 CHCP65LCDBoard::NumIgnored(void)
{
	uint64	uiIgnored;

	mcMutex.Lock();
	uiIgnored = mcController.NumIgnored();
	mcMutex.Unlock();
	return uiIgnored;
}
