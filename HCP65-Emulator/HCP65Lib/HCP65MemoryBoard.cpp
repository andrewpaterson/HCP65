#include <stdlib.h>
#include <string.h>
#include "BaseLib/PointerFunctions.h"
#include "HCP65.h"
#include "HCP65MemoryBoard.h"


//The channel's sockets in register order, S to Z, as device slots: -1 where the small mainboard has none.
static const int	gaiHCP65MemorySocketSlots[HCP65_MEMORY_NUM_SOCKETS] = { -1, -1, 19, 18, 4, 3, 17, 16 };


//////////////////////////////////////////////////////////////////////////
//
// Its memory starts as zeros.  It is a 32KB device: only its ROM is in
// its slot.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryBoard::Init(void)
{
	CHCP65Device::Init(HCP65_SMALL_SLOT_SIZE);
	mcROM.Init(HCP65_MEMORY_BOARD_NAME, HCP65_DEVICE_MANUFACTURER, 0, DEVICE_BUS_32KB, DEVICE_MAIN_BUS_WINDOW_A | DEVICE_MAIN_BUS_WINDOW_B, "");
	mpuiMemory = (uint8*)calloc(1, 2 * HCP65_MEMORY_CHIP_SIZE);
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryBoard::Kill(void)
{
	SafeFree(mpuiMemory);
	CHCP65Device::Kill();
}


//////////////////////////////////////////////////////////////////////////
//
// The device ROM; nothing else is decoded in the slot.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65MemoryBoard::Read(uint32 uiOffset)
{
	return (uiOffset < DEVICE_ROM_SIZE) ? mcROM.Read(uiOffset) : 0xFF;
}


//////////////////////////////////////////////////////////////////////////
//
// The device ROM is flash.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryBoard::Write(uint32 uiOffset, uint8 uiValue)
{
}


//////////////////////////////////////////////////////////////////////////
//
// Chip A (0) or chip B (1): HCP65_MEMORY_CHIP_SIZE bytes.
//
//////////////////////////////////////////////////////////////////////////
uint8* CHCP65MemoryBoard::GetMemoryChip(int iChip)
{
	if ((iChip < 0) || (iChip > 1))
	{
		return NULL;
	}
	return &mpuiMemory[(size)iChip * HCP65_MEMORY_CHIP_SIZE];
}


//////////////////////////////////////////////////////////////////////////
//
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryChannel::Init(void)
{
	CHCP65Device::Init(HCP65_SMALL_SLOT_SIZE);
	Reset();
}


//////////////////////////////////////////////////////////////////////////
//
// The registers can't be read: nothing drives the bus.
//
//////////////////////////////////////////////////////////////////////////
uint8 CHCP65MemoryChannel::Read(uint32 uiOffset)
{
	return 0xFF;
}


//////////////////////////////////////////////////////////////////////////
//
// Register 0 or 1, repeating every 8 bytes.  The HCP65 maps main memory
// again.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryChannel::Write(uint32 uiOffset, uint8 uiValue)
{
	if ((uiOffset & 7) < 2)
	{
		mauiRegisters[uiOffset & 7] = uiValue;
		if (mpcHCP65)
		{
			mpcHCP65->MapMainMemory();
		}
	}
}


//////////////////////////////////////////////////////////////////////////
//
// Every socket in window 0.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryChannel::Reset(void)
{
	mauiRegisters[0] = 0;
	mauiRegisters[1] = 0;
	if (mpcHCP65)
	{
		mpcHCP65->MapMainMemory();
	}
}


//////////////////////////////////////////////////////////////////////////
//
// The channel is the mainboard's: the device enables don't reach it.
//
//////////////////////////////////////////////////////////////////////////
void CHCP65MemoryChannel::SetHeldInReset(bool bHeld)
{
}


//////////////////////////////////////////////////////////////////////////
//
// The device slot of socket iSocket (0 to 7, S to Z), -1 if there is none.
//
//////////////////////////////////////////////////////////////////////////
int CHCP65MemoryChannel::GetSocketSlot(int iSocket)
{
	return ((iSocket >= 0) && (iSocket < HCP65_MEMORY_NUM_SOCKETS)) ? gaiHCP65MemorySocketSlots[iSocket] : -1;
}


//////////////////////////////////////////////////////////////////////////
//
// The window (0 to 3) socket iSocket's chips answer.
//
//////////////////////////////////////////////////////////////////////////
int CHCP65MemoryChannel::GetSocketWindow(int iSocket)
{
	return (mauiRegisters[iSocket >> 2] >> (2 * (iSocket & 3))) & 3;
}
